<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sam_libjpeg.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>build_all_project</name>
      <member>
        <project>sam_libjpeg</project>
        <configuration>Debug_CM3</configuration>
      </member>
      <member>
        <project>sam_libjpeg</project>
        <configuration>Debug_CM4</configuration>
      </member>
      <member>
        <project>sam_libjpeg</project>
        <configuration>Debug_CM4F</configuration>
      </member>
      <member>
        <project>sam_libjpeg</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>sam_libjpeg</project>
        <configuration>Release_CM3</configuration>
      </member>
      <member>
        <project>sam_libjpeg</project>
        <configuration>Release_CM4</configuration>
      </member>
      <member>
        <project>sam_libjpeg</project>
        <configuration>Release_CM4f</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


