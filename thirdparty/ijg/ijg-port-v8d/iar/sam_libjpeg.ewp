# IAR project sam_libjpeg.ewp, settings and files
configuration Debug_CM3 (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..; ../../v8d
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sam_libjpeg.srec
  ILINK.IlinkOutputFile: sam_libjpeg.out
configuration Debug_CM4F (ARM, debug)
  as the first configuration, except:
configuration Debug_CM4 (ARM, debug)
  as the first configuration, except:
configuration Release_CM3 (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration Release_CM4 (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration Release_CM4f (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group (top)
    ../: libjpeg.c libjpeg.h
  group headers
    ../../v8d/: cdjpeg.h jinclude.h jmorecfg.h jpeglib.h
  group headers for sram
    ../: jconfig.h jconfig_as.h jconfig_gcc.h jconfig_iar.h
  group source
    ../../v8d/: jcapimin.c jcapistd.c jcomapi.c jcparam.c jctrans.c jdapimin.c jdapistd.c jdtrans.c
  group source/common
    ../../v8d/: jaricom.c jerror.c jmemmgr.c jmemnobs.c jutils.c
  group source/compression
    ../../v8d/: jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcprepct.c jcsample.c jfdctflt.c jfdctfst.c jfdctint.c
    ../: jdatadst_mem.c
  group source/decompression
    ../../v8d/: jdarith.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jidctflt.c jidctfst.c jidctint.c jquant1.c jquant2.c
    ../: jdatasrc_mem.c
