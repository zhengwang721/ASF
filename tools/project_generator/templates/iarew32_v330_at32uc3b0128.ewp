# IAR project iarew32_v330_at32uc3b0128.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 1
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
configuration Release (AVR32)
  as the first configuration, except:
